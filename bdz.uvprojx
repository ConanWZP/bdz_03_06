# Keil uVision project bdz.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: bdz
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: C:\bdz_29_30-main;.\RTE\Device\STM32F407VGTx
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source Group 1
    ./: main.c keyboard.c keyboard.h adcTermo.c adcTermo.h termoresistor.c termoresistor.h WH1602B.c WH1602B.h leds.c leds.h initTim4.c initTim4.h initShim.c initShim.h pwmSetPulse.c pwmSetPulse.h timerForDisplay.c timerForDisplay.h initPinsDisplay.c initPinsDisplay.h button.c button.h initKeys.c initKeys.h
software components: CMSIS:CORE 5.6.0, Device:STM32Cube Framework:Classic 1.7.13, Device:STM32Cube HAL:ADC 1.7.13, Device:STM32Cube HAL:Common 1.7.13, Device:STM32Cube HAL:Cortex 1.7.13, Device:STM32Cube HAL:DAC 1.7.13, Device:STM32Cube HAL:DMA 1.7.13, Device:STM32Cube HAL:EXTI 1.7.13, Device:STM32Cube HAL:GPIO 1.7.13, Device:STM32Cube HAL:PWR 1.7.13, Device:STM32Cube HAL:RCC 1.7.13, Device:STM32Cube HAL:SPI 1.7.13, Device:STM32Cube HAL:TIM 1.7.13, Device:STM32Cube HAL:UART 1.7.13, Device:Startup 2.6.3
